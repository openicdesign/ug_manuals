.control
run
save all
.endc
